## project/Kconfig.proj
```kconfig
config CUSTOM_MEM_MAP
    bool
    select custom_mem_map
    default y if !SOC_SIMULATOR

source "$POCKETJS_ROOT/platforms/sifli/Kconfig"
```
